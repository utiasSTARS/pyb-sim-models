Commit message: Fixed the default inertia of the composite object in compositeH.urdf.

File: pbsm/models/CompositeTestObject/urdf/compositeH.urdf (robot description, URDF)
Before this commit: robot compositeH, 1 links, 0 joints
Links:
- link object: mass 2.16 -> 0.352
